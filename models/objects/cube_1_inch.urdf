Commit message: add models

File: models/objects/cube_1_inch.urdf (robot description, URDF)
Before this commit: robot cube1, 2 links, 0 joints
Links:
- removed link link_cube1
- added link link_cube_1_inch, mass 0.006; collision box size=0.0254 0.0254 0.0254; visual box size=0.0254 0.0254 0.0254
